FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://cirthfb.cfg"
